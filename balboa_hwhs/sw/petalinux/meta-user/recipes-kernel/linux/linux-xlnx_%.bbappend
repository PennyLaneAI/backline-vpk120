# SPDX-License-Identifier: Apache-2.0
# Copyright 2026 Xanadu Quantum Technologies Inc.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://uio.cfg"
