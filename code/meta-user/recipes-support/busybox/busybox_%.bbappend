FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += " file://blacklist.cfg"